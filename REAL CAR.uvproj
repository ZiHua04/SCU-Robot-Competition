# Keil uVision project REAL CAR.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: REAL CAR +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Timer0.c main.c motor.c Delay.c car.c xunji.c duoji.c
